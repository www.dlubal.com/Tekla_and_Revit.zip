page("TeklaStructures","")
{
   macro(1, "NVS100")
   {
       helpurl("cchelp_usa_vendor_embeds")
       tab_page("", " Parameters ", 1)
       {
           parameter("Class", "P1", integer, number, 1)
           parameter("Finish", "P2", string, text, 2)
           parameter("Material", "P3", material, text, 3)
       }
   }
}