page("TeklaStructures","")
{
   joint(1, "Thickened Slab")
   {
       helpurl("cchelp_usa_thickened_slab")
       tab_page("", " Parameters ", 1)
       {
           parameter("Material", "P7", material, text, 1) 
           parameter("", "P1", distance, number, 525,250,60)
           parameter("", "P3", distance, number, 350,390,60)
           parameter("", "P4", distance, number, 350,460,60)

	   picture("usa_thickened_slab.bmp",0, 0, 150, 150)
       }
   }
}