page("TeklaStructures","")
{
   macro(1, "Hurricane tie (H2_5)")
   {
       helpurl("cchelp_usa_wood_connectors")
       tab_page("", " Design ", 1)
       {
           parameter("Design Name", "P1", string, text, 1)
           parameter("Class", "P2", integer, number, 2)
           parameter("Bought Out Item / Catalog Number", "P4", string, text, 3)
       }
   }
}