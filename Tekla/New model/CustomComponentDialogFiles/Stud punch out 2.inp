page("TeklaStructures", "")
{
    detail(1, "Stud punch out 2")
    {
        helpurl("cchelp_usa_metal_stud_punch_out_components")
        tab_page("", "Location of cuts", 1)
        {
            picture("usa_ms_PO2", 272, 251, 87, 96)
            attribute("", "Desired spacing", label, "%s", none, none, "0", "0", 410, 209)
            parameter("", "P2", distance, number, 410, 233, 105)
            parameter("", "P1", distance, number, 410, 305, 105)
        }
    }
}
