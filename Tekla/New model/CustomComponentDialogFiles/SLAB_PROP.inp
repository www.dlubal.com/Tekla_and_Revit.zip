page("TeklaStructures","")
{
   macro(1, "SLAB_PROP")
   {
       tab_page("", " Parameters 1 ", 1)
       {
           parameter("Height", "P1", distance, number, 1)
       }
   }
}