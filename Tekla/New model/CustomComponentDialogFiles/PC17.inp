page("TeklaStructures", "")
{
    macro(1, "PC17")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC17", 543, 433, 101, 84)
        }
    }
}
