page("TeklaStructures","")
{
   macro(1, "General_Tie")
   {
       helpurl("cchelp_usa_additional_formwork_components")
       tab_page("", "j_Parameters", 1)
       {
           picture("Tekla_Tie", 320,80,100,50)
           profile("Tie Profile", GTTProf, GTTMark, GTTMat, , GTTName,10)
           profile("Spacer Profile", GTSProf, GTSMark, GTSMat, , GTSName,11)
           attribute(" ","j_class",label,"%s",none,none,"0","0", 840,220)
           parameter("", "GTExtDim", distance, number, 70,30,80)
           parameter("", "GTSLength", distance, number, 180,30,80)
           parameter("", "GTTClass", integer, number, 840,240,80)
           parameter("", "GTSClass", integer, number, 840,265,80)
           parameter("", "CR_Spacer", YesNo, number, 400,40,60)
       }
       tab_page("", "j_input_example", 2)
       {
           picture("Tekla_Tie_Input", 250,150,190,50)
           attribute(" ","1. Select Input point 1",label,"%s",none,none,"0","0", 20,300)
           attribute(" ","2. Select Input point 2",label,"%s",none,none,"0","0", 20,320)
       }
   }
}