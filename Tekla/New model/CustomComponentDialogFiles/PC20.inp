page("TeklaStructures", "")
{
    macro(1, "PC20")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC20", 612, 438, 101, 84)
        }
    }
}
