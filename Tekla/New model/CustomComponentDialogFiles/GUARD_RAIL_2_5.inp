page("TeklaStructures","")
{
   macro(1, "GUARD_RAIL_2_5")
   {
       tab_page("", " Parameters 1 ", 1)
       {
       }
   }
}