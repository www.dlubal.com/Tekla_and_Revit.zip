page("TeklaStructures", "")
{
    macro(1, "PC10")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC10", 482, 295, 87, 78)
        }
    }
}
