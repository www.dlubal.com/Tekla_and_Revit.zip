page("TeklaStructures","")
{
   macro(1, "PNA Dowel (1_4)")
   {
        helpurl("cchelp_usa_pna_construction_technologies")	
       tab_page("", " Parameters ", 1)
       {
       }
   }
}