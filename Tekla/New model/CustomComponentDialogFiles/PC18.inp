page("TeklaStructures", "")
{
    macro(1, "PC18")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC18", 544, 432, 101, 78)
        }
    }
}
