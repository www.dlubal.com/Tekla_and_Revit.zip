page("TeklaStructures", "")
{
    macro(1, "PC26")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC26", 677, 536, 114, 96)
        }
    }
}
