page("TeklaStructures","")
{
   macro(1, "AS1")
   {
       helpurl("cchelp_usa_embed_assemblies")
       tab_page("", " Parameters 1 ", 1)
       {
           parameter("Class", "P1", integer, number, 1)
           parameter("Finish", "P2", string, text, 2)
           parameter("Material", "P3", material, text, 3)
           parameter("Nut Profile", "P4", profile, text, 4)
       }
   }
}