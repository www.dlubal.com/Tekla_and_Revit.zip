page("TeklaStructures", "")
{
    macro(1, "PC23")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC23", 610, 514, 114, 90)
        }
    }
}
