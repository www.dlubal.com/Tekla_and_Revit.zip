page("TeklaStructures", "")
{
    macro(1, "PC28")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC28", 670, 540, 114, 96)
        }
    }
}
