page("TeklaStructures", "")
{
    macro(1, "PC19")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC19", 579, 434, 101, 90)
        }
    }
}
