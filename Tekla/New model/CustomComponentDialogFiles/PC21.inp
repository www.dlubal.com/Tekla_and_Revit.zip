page("TeklaStructures", "")
{
    macro(1, "PC21")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC21", 589, 516, 108, 78)
        }
    }
}
