page("TeklaStructures","")
{
   macro(1, "I-Joist hanger (IUS)")
   {
       helpurl("cchelp_usa_wood_connectors")
       tab_page("", " Design ", 1)
       {
           parameter("Name / Design Name", "P1", string, text, 1)
           parameter("Class", "P2", integer, number, 2)
           parameter("Bought Out Item Name/Catalog Number", "P4", string, text, 3)
       }
   }
}