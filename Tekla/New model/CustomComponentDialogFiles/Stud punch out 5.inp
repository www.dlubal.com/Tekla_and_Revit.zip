page("TeklaStructures", "")
{
    detail(1, "Stud punch out 5")
    {
        helpurl("cchelp_usa_metal_stud_punch_out_components")
        tab_page("", "Location of cuts ", 1)
        {
            picture("usa_ms_PO5", 293, 273, 94, 102)
            attribute("", "Desired spacing", label, "%s", none, none, "0", "0", 436, 183)
            parameter("", "P2", distance, number, 436, 207, 104)
            parameter("", "P1", distance, number, 436, 315, 104)
        }
    }
}
