page("TeklaStructures", "")
{
    macro(1, "PC13")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC13", 544, 324, 94, 78)
        }
    }
}
