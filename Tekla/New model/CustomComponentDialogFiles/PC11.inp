page("TeklaStructures", "")
{
    macro(1, "PC11")
    {
        helpurl("cchelp_usa_pile_caps")
        tab_page("", "Picture", 1)
        {
            picture("usa_PC11", 483, 295, 101, 84)
        }
    }
}
